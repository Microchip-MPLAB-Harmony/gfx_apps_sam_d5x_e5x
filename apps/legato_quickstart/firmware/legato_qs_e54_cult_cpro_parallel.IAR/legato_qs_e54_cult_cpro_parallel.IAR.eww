<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\legato_qs_e54_cult_cpro_parallel.IAR.ewp</path>
    </project>
</workspace>
