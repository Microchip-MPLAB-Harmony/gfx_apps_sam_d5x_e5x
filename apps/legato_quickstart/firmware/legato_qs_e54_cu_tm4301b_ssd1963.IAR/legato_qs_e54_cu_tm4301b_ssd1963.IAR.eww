<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\legato_qs_e54_cu_tm4301b_ssd1963.IAR.ewp</path>
    </project>
</workspace>
